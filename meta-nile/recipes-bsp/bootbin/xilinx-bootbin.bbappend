do_configure:append:vb8034[depends] = " virtual/kernel:do_deploy"